# Keil uVision project wifi.uvprojx, settings and files
target mcu_wifi (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wifi +hex
  AfterMake: hex2bin.exe   .\out\wifi.hex
  c flags: Optim=1 wLevel=2
  c define: __FPU_PRESENT=1,ARM_MATH_CM4,OS_UCOS,HSE_VALUE=25000000,MEM_MAN_MODE=1,HAVE_CONFIG_H,ENABLE_LCD=0,NO_WIFI,WIFI_CHIP=8782,HW_VER=2,SUPPORT_AUDIO=0
  c misc: --diag_suppress 1035,188,68,161,1441
  c include: ..\..\net\lwip\src\include\ipv4;..\..\net\lwip\src\include;..\..\net\lwip\src\arch;..\..\net\lwip\src;..\..\kernel\ucos\include;..\..\kernel\api\inc;..\..\app\inc;..\..\config;..\..\jpeg\jpeg-9a;..\..\net\udhcp-0.9.8;..\..\libmad-0.15.1b;..\..\net\libertas\inc;..\..\net\wpa;..\..\net\wlan_src\mlan;..\..\net\wlan_src\mlinux;..\..\net\wlan_src\user;..\..\net\wlan_src\mapp;..\..\net\wlan_src\mapp\wifidirectutl;..\..\net\mosquitto-1.3.4\lib;..\..\bsp\stm32f4xx\CMSIS\inc;..\..\bsp\stm32f4xx\FWlib4xx\inc;..\..\drivers\stm32f4xx\inc;..\..\Speex_Lib\include;..\..\Speex_Lib\libspeex;..\..\net\cjson;..\..\drivers\stm32f4xx\usb\STM32_USB_HOST_Library\inc;..\..\drivers\stm32f4xx\usb\STM32_USB_OTG_Driver\inc;..\..\drivers\stm32f4xx\usb\inc;..\..\drivers\stm32f4xx\usb\Class\MSC\Inc;..\..\ff11a\src;..\..\net\dhcpd;..\..\app\src\httpd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --remove
  group bsp
    ../../bsp/stm32f4xx/CMSIS/src/: system_stm32f4xx.c startup_stm32f4xx.s
    ../../bsp/stm32f4xx/FWlib4xx/src/: misc.c stm32f4x7_eth.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group os
    ../../kernel/ucos/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../kernel/ucos/uCOS-II/Ports/ARM-Cortex-M3/IAR/: os_cpu_c.c os_cpu_a.asm
  group os_api
    ../../kernel/api/src/: atomic.c memory.c task.c memory2.c mbox.c msg_q.c mutex.c sem.c timer.c wait.c
  group lwip_api
    ../../net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_arch
    ../../net/lwip/src/arch/: sys_arch.c
  group lwip_core
    ../../net/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c _timers.c udp.c
    ../../net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_netif
    ../../net/lwip/src/netif/: etharp.c eth_ethernetif.c
  group mosquitto
    ../../net/mosquitto-1.3.4/lib/: logging_mosq.c memory_mosq.c messages_mosq.c mosquitto.c net_mosq.c read_handle.c read_handle_client.c read_handle_shared.c send_client_mosq.c send_mosq.c srv_mosq.c thread_mosq.c time_mosq.c tls_mosq.c util_mosq.c will_mosq.c
  group speex
    ../../Speex_Lib/libspeex/: buffer.c cb_search.c exc_5_64_table.c exc_5_256_table.c exc_8_128_table.c exc_10_16_table.c exc_10_32_table.c exc_20_32_table.c fftwrap.c filterbank.c filters.c gain_table.c gain_table_lbr.c hexc_10_32_table.c hexc_table.c high_lsp_tables.c jitter.c kiss_fft.c kiss_fftr.c lpc.c lsp.c lsp_tables_nb.c ltp.c mdf.c modes.c modes_wb.c nb_celp.c preprocess.c quant_lsp.c resample.c sb_celp.c smallft.c speex.c speex_callbacks.c speex_header.c stereo.c vbr.c vq.c window.c bits.c
  group drivers
    ../../drivers/stm32f4xx/src/: audio_low_level.c camera.c dht11.c driver_misc.c hard_timer.c ir_control.c lan8720.c MFRC522.C rtc.c sccb.c usart.c w25p80.c ov2640.c stm32f4xx_it.c key.c 24l01.c
  group app
    ../../app/src/: debug.c sys_misc.c main.c test_tcpip.c tcpapp.c sensers.c work.c mqtt_app.c test.c
    ../../app/src/audio/: audio.c adpcm.c
    ../../net/wpa/: sha1.c
    ../../app/src/httpd/: web_cfg.c
  group readme
    ../../doc/: 版本说明.txt
  group onenet
    ../../onenet/c/: cJSON.c edp_demo.c EdpKit.c uMem.c
software components: CMSIS:CORE 4.1.0
