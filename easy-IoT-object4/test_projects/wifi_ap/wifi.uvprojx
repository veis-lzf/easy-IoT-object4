# Keil uVision project wifi.uvprojx, settings and files
target mcu_wifi (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wifi +hex
  AfterMake: hex2bin.exe   .\out\wifi.hex
  c flags: Optim=1 wLevel=2
  c define: __FPU_PRESENT=1,ARM_MATH_CM4,OS_UCOS,HSE_VALUE=25000000,MEM_MAN_MODE=1,HAVE_CONFIG_H,ENABLE_LCD=0,WIFI_CHIP=8782,HW_VER=3,SUPPORT_AUDIO=0
  c misc: --diag_suppress 1035,188,68,161,1441
  c include: ..\..\net\lwip\src\include\ipv4;..\..\net\lwip\src\include;..\..\net\lwip\src\arch;..\..\net\lwip\src;..\..\kernel\ucos\include;..\..\kernel\api\inc;..\..\app\inc;..\..\config;..\..\jpeg\jpeg-9a;..\..\net\udhcp-0.9.8;..\..\libmad-0.15.1b;..\..\net\libertas\inc;..\..\net\wpa;..\..\net\wlan_src\mlan;..\..\net\wlan_src\mlinux;..\..\net\wlan_src\user;..\..\net\wlan_src\mapp;..\..\net\wlan_src\mapp\wifidirectutl;..\..\net\mosquitto-1.3.4\lib;..\..\bsp\stm32f4xx\CMSIS\inc;..\..\bsp\stm32f4xx\FWlib4xx\inc;..\..\drivers\stm32f4xx\inc;..\..\Speex_Lib\include;..\..\Speex_Lib\libspeex;..\..\net\cjson
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --remove
  group bsp
    ../../bsp/stm32f4xx/CMSIS/src/: system_stm32f4xx.c startup_stm32f4xx.s
    ../../bsp/stm32f4xx/FWlib4xx/src/: misc.c stm32f4x7_eth.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group os
    ../../kernel/ucos/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../kernel/ucos/uCOS-II/Ports/ARM-Cortex-M3/IAR/: os_cpu_c.c os_cpu_a.asm
  group os_api
    ../../kernel/api/src/: atomic.c memory.c task.c memory2.c mbox.c msg_q.c mutex.c sem.c timer.c wait.c
  group mlinux
    ../../net/wlan_src/mlinux/: moal_main.c moal_cfg80211.c moal_debug.c moal_ioctl.c moal_proc.c moal_sdio_mmc.c moal_shim.c moal_sta_cfg80211.c moal_uap_cfg80211.c moal_uap.c moal_uap_priv.c
  group mlan
    ../../Speex_Lib/libspeex/: bits.c
    ../../net/wlan_src/mlan/: mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_cfp.c mlan_cmdevt.c mlan_init.c mlan_join.c mlan_meas.c mlan_misc.c mlan_scan.c mlan_sdio.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_sta_tx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_uap_txrx.c mlan_wmm.c
  group muser
    ../../net/wlan_src/user/: skbuff.c usr_cfg.c
    ../../net/wpa/: sha1.c
  group drivers
    ../../drivers/stm32f4xx/src/: driver_misc.c sdcard.c usart.c
  group app
    ../../app/src/: sys_misc.c wifi.c
    ./: main.c
  group readme
    ../../doc/: 版本说明.txt
software components: CMSIS:CORE 4.1.0
