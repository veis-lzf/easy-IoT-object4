# Keil uVision project easyIoT.uvprojx, settings and files
target code (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wifi +hex
  AfterMake: hex2bin.exe   .\out\wifi.hex
  c flags: Optim=3 uC99=1 wLevel=2
  c define: STM32F40_41xxx,HSE_VALUE=8000000,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,ARM_MATH_CM4,OS_UCOS,HSE_VALUE=8000000,MEM_MAN_MODE=1,HAVE_CONFIG_H,WIFI_CHIP=8782,HW_VER=2,ENABLE_LCD=0,SUPPORT_WIFI=1
  c misc: --diag_suppress 1035,188,68,161,1441
  c include: ..\..\net\lwip\src\include\ipv4;..\..\net\lwip\src\include;..\..\net\lwip\src\arch;..\..\net\lwip\src;..\..\kernel\ucos\include;..\..\kernel\api\inc;..\..\app\inc;..\..\config;..\..\jpeg\jpeg-9a;..\..\net\udhcp-0.9.8;..\..\libmad-0.15.1b;..\..\net\libertas\inc;..\..\net\wpa;..\..\net\wlan_src\mlan;..\..\net\wlan_src\mlinux;..\..\net\wlan_src\user;..\..\net\wlan_src\mapp;..\..\net\wlan_src\mapp\wifidirectutl;..\..\bsp\stm32f4xx\CMSIS\inc;..\..\bsp\stm32f4xx\FWlib4xx\inc;..\..\drivers\stm32f4xx\inc;..\..\Speex_Lib\include;..\..\Speex_Lib\libspeex;..\..\net\cjson;..\..\drivers\stm32f4xx\usb\STM32_USB_HOST_Library\inc;..\..\drivers\stm32f4xx\usb\STM32_USB_OTG_Driver\inc;..\..\drivers\stm32f4xx\usb\inc;..\..\drivers\stm32f4xx\usb\Class\MSC\Inc;..\..\ff11a\src;..\..\net\dhcpd;..\..\onenet\c\;..\..\app\src\httpd;..\..\iotx-sdk-c\src\auth;..\..\iotx-sdk-c\src\libs\mbedtls\include;..\..\iotx-sdk-c\src\libs\mbedtls\configs\linux;..\..\iotx-sdk-c\src\mqtt\MQTTPacket;..\..\iotx-sdk-c\src\platform\os\linux;..\..\iotx-sdk-c\src\platform\ssl\mbedtls;..\..\iotx-sdk-c\src\system;..\..\iotx-sdk-c\src\utility;..\..\iotx-sdk-c\src\libs\mbedtls\include\mbedtls;..\..\iotx-sdk-c\src\mqtt;..\..\baidu-ai;..\..\use
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --remove
  group bsp
    ../../bsp/stm32f4xx/CMSIS/src/: system_stm32f4xx.c startup_stm32f4xx.s
    ../../bsp/stm32f4xx/FWlib4xx/src/: misc.c stm32f4x7_eth.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group os
    ../../kernel/ucos/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../kernel/ucos/uCOS-II/Ports/ARM-Cortex-M3/IAR/: os_cpu_c.c os_cpu_a.asm
  group os_api
    ../../kernel/api/src/: atomic.c memory.c task.c memory2.c mbox.c msg_q.c mutex.c sem.c timer.c wait.c
  group lwip_api
    ../../net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_arch
    ../../net/lwip/src/arch/: sys_arch.c
  group lwip_core
    ../../net/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c _timers.c udp.c
    ../../net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_netif
    ../../net/lwip/src/netif/: ethernetif.c etharp.c eth_ethernetif.c
  group udhcp
    ../../net/dhcpd/: dhcpserver.c
  group mlinux
    ../../net/wlan_src/mlinux/: moal_main.c moal_cfg80211.c moal_debug.c moal_ioctl.c moal_proc.c moal_sdio_mmc.c moal_shim.c moal_sta_cfg80211.c moal_uap_cfg80211.c moal_uap.c moal_uap_priv.c
  group mlan
    ../../Speex_Lib/libspeex/: bits.c
    ../../net/wlan_src/mlan/: mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_cfp.c mlan_cmdevt.c mlan_init.c mlan_join.c mlan_meas.c mlan_misc.c mlan_scan.c mlan_sdio.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_sta_tx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_uap_txrx.c mlan_wmm.c
  group muser
    ../../net/wlan_src/user/: skbuff.c usr_cfg.c
    ../../net/wpa/: sha1.c
  group libmad
    ../../libmad-0.15.1b/: bit.c decoder.c fixed.c frame.c huffman.c layer3.c layer12.c mad_timer.c madlld.c stream.c synth.c version.c
  group speex
    ../../Speex_Lib/libspeex/: buffer.c cb_search.c exc_5_64_table.c exc_5_256_table.c exc_8_128_table.c exc_10_16_table.c exc_10_32_table.c exc_20_32_table.c fftwrap.c filterbank.c filters.c gain_table.c gain_table_lbr.c hexc_10_32_table.c hexc_table.c high_lsp_tables.c jitter.c kiss_fft.c kiss_fftr.c lpc.c lsp.c lsp_tables_nb.c ltp.c mdf.c modes.c modes_wb.c nb_celp.c preprocess.c quant_lsp.c resample.c sb_celp.c smallft.c speex.c speex_callbacks.c speex_header.c stereo.c vbr.c vq.c window.c
  group drivers
    ../../drivers/stm32f4xx/src/: audio_low_level.c camera.c dht11.c driver_misc.c hard_timer.c ir_control.c lan8720.c MFRC522.C rtc.c sccb.c sdcard.c key.c usart.c w25p80.c ov2640.c stm32f4xx_it.c 24l01.c BH1750FVI.c mq2.c lamp_pwm_control.c
    ../../use/: dcmi.c net_cemera.c
  group usb_driver
    ../../drivers/stm32f4xx/usb/src/: usb_bsp.c usbh_usr.c
    ../../drivers/stm32f4xx/usb/STM32_USB_HOST_Library/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../drivers/stm32f4xx/usb/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group usb_class_msc
    ../../drivers/stm32f4xx/usb/Class/MSC/Src/: usbh_msc_core.c usbh_msc_bot.c usbh_msc_scsi.c usbh_msc_fatfs.c
  group fatfs
    ../../ff11a/src/: diskio.c ff.c
    ../../ff11a/src/option/: ccsbcs.c syscall.c
  group app
    ../../app/src/httpd/: web_cfg.c
    ../../app/src/: debug.c sys_misc.c main.c wifi.c test_wifi.c test_tcpip.c tcpapp.c sensers.c work.c test.c test_fs.c onenet_http_control.c
    ../../app/src/audio/: audio.c adpcm.c
  group readme
    ../../doc/: 版本说明.txt
  group onenet
    ../../onenet/c/: edp_demo.c EdpKit.c cJSON.c uMem.c
  group aliyun-auth
    ../../iotx-sdk-c/src/auth/: aliyun_iot_auth.c
  group aliyun-libs
    ../../iotx-sdk-c/src/libs/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group aliyun-mqtt
    ../../iotx-sdk-c/src/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../../iotx-sdk-c/src/mqtt/: aliyun_iot_mqtt_client.c
  group aliyun-platform
    ../../iotx-sdk-c/src/platform/os/linux/: aliyun_iot_platform_memory.c aliyun_iot_platform_network.c aliyun_iot_platform_pthread.c aliyun_iot_platform_random.c aliyun_iot_platform_sem.c aliyun_iot_platform_timer.c
    ../../iotx-sdk-c/src/platform/ssl/mbedtls/: aliyun_iot_network_ssl.c
  group aliyun-system
    ../../iotx-sdk-c/src/system/: aliyun_iot_ca.c aliyun_iot_device.c
  group aliyun-utility
    ../../iotx-sdk-c/src/utility/: aliyun_iot_common_base64.c aliyun_iot_common_hexdump.c aliyun_iot_common_hmac.c aliyun_iot_common_httpclient.c aliyun_iot_common_jsonparser.c aliyun_iot_common_list.c aliyun_iot_common_log.c aliyun_iot_common_md5.c aliyun_iot_common_net.c aliyun_iot_common_sha1.c aliyun_iot_common_timer.c
  group aliyun-sample
    ../../iotx-sdk-c/sample/mqtt/: mqtt.c
  group baidu-ai
    ../../baidu-ai/: baidu_ai_face.c baidu_ai_voice.c
  group web
    ../../use/: web_server.c
  group gui
    ../../use/: jpeg_pic.c
  group txet
    ../../use/: fontupd.c text.c
  group interface
    ../../use/: interface.c
software components: CMSIS:CORE 5.4.0
